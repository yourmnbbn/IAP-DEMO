# Keil uVision project Cortex-M3 Execute for lpc1700.uvprojx, settings and files
target DebugInFlash (5040049::V5.04 update 1 (build 49)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: Cortex-M3-Execute-for-lpc1700 +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: DEBUG
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
  group USER_CODE
    ./USER_CODE/: main.c bitband.h
  group ZY_CODE
    ./ZY_CODE/Startup/: LPC1700PinCfg.c target.c vector_table.c lpc1700.h target.h
    ./ZY_CODE/: firmware.h
    ./ZY_CODE/zy_if/: zy_if.c zy_if.h
  group cfg_file
    ./: config.h
    ./cfg_file/: target_cfg.h
    ./cfg_file/Startup/: LPC1700PinCfg.h rt_sys_s.s rt_sys_c.c vector_cfg.h
    ./cfg_file/zy_if/: zy_if_cfg.h
target Release (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Cortex-M3 Execute for lpc1700
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RELEASE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
